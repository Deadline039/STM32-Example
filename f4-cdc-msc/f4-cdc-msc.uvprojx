# Keil uVision project f4-cdc-msc.uvprojx, settings and files
target f4-cdc-msc (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  output: f4-cdc-msc
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,DEBUG,STM32F429xx,USE_USB_FS,USE_USBD_COMPOSITE
  c include: Drivers\CMSIS\Core\Include;Drivers\STM32_HAL_Driver\Inc;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CSP\Config;Drivers\Bsp;User\Application\Inc;User\Utils;Middlewares\FreeRTOS\include;Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;Middlewares\FATFS;Middlewares\USB\USB_APP;Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;Middlewares\USB\STM32_USB_Device_Library\Core\Inc;Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc
  asm define: as above
  memory RVCT1: RAM 0x08000000 size 0x00100000
  memory RVCT6: RAM 0x20000000 size 0x00030000
  memory RVCT7: RAM 0x10000000 size 0x00010000
  group Utils
    User/Utils/ring_fifo/: ring_fifo.c
  group Middlewares/USB/APP
    Middlewares/USB/USB_APP/: usbd_conf.c usbd_storage_if.c usbd_cdc_if.c usbd_desc.c usbd_composite.c
  group Middlewares/USB/Core
    Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB/Class/CDC
    Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/USB/Class/MSC
    Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_msc.c
  group Middlewares/FATFS
    Middlewares/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/FreeRTOS/Portable
    Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS/Core
    Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/CSP
    Drivers/CSP/: UART_STM32F4xx.c CAN_STM32F4xx.c ETH_STM32F4xx.c I2C_STM32F4xx.c RTC_STM32F4xx.c SPI_STM32F4xx.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/CMSIS/Startup
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/HAL_Driver
    Drivers/STM32_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c
  group Application
    User/Application/Src/: main.c stm32f4xx_it.c rtos_tasks.c devices.c usb_app.c
  group Bsp
    Drivers/Bsp/core/: bsp_core.c core_delay.c retarget_io.c
    Drivers/Bsp/key/: key.c
    Drivers/Bsp/led/: led.c
    Drivers/Bsp/: bsp.c
    Drivers/Bsp/lcd/: lcd.c
    Drivers/Bsp/sdram/: sdram.c
    Drivers/Bsp/ltdc/: ltdc.c
    Drivers/Bsp/touch/: touch.c
    Drivers/Bsp/sd_card/: sdio_sdcard.c
    Drivers/Bsp/nand/: ftl.c nand.c
    Drivers/Bsp/at24cxx/: at24cxx.c
